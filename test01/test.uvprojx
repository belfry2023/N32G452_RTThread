# Keil uVision project test.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G452VEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --no_multibyte_chars --fpu=SoftVFP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\RTE\RT-Thread_Full\N32G452VEL7\n32g452_rtthread.sct
  group User
    ./: main.c
software components: RT-Thread Full:Kernel 0.1.1, RT-Thread Full:Board 0.1.1, RT-Thread Full:GP21 0.1.1, RT-Thread Full:GC9307C 0.1.1, RT-Thread Full:LVGL 0.1.1
