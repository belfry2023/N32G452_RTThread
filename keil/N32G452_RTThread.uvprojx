# Keil uVision project N32G452_RTThread.uvprojx, settings and files
target AC5_Headless (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: N32G452VEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(128000000) ELITTLE
  output: n32g452_rtthread +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X,N32G452,USE_STDPERIPH_DRIVER,N32_USE_RTTHREAD=1,N32_VARIANT_xE,SYSCLK_SRC=2,SYSCLK_FREQ=128000000,HSE_VALUE=8000000
  c misc: --c99 --fpu=SoftVFP --no_multibyte_chars
  c include: ..\board;..\inc;..\Nations.N32G45x_Library.2.6.0\firmware\CMSIS\core;..\Nations.N32G45x_Library.2.6.0\firmware\CMSIS\device;..\Nations.N32G45x_Library.2.6.0\firmware\n32g45x_std_periph_driver\inc;..\Nations.N32G45x_Library.2.6.0\middlewares\rt-thread\include;..\Nations.N32G45x_Library.2.6.0\middlewares\rt-thread\components\drivers\include;..\Nations.N32G45x_Library.2.6.0\middlewares\rt-thread\components\drivers\include\ipc;..\Nations.N32G45x_Library.2.6.0\middlewares\rt-thread\components\finsh;..\third_party\lvgl
  asm misc: --fpu=SoftVFP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: ..\pack\keil\n32g452_rtthread.sct
  link misc: --entry=Reset_Handler --keep=*(.rti_fn*) --keep=*(FSymTab) --keep=*(VSymTab) --keep=*(HEAP) --keep=*(STACK)
  group Kernel
    ../pack/keil/: finsh_vars.c
    generated/: hwtimer.c
    ../Nations.N32G45x_Library.2.6.0/middlewares/rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    ../Nations.N32G45x_Library.2.6.0/middlewares/rt-thread/components/drivers/serial/: serial.c
    ../Nations.N32G45x_Library.2.6.0/middlewares/rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    ../Nations.N32G45x_Library.2.6.0/middlewares/rt-thread/components/drivers/src/: completion.c dataqueue.c
    ../Nations.N32G45x_Library.2.6.0/middlewares/rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c shell.c symbol.c
    ../Nations.N32G45x_Library.2.6.0/middlewares/rt-thread/libcpu/cortex-m4/: cpuport.c
    ../Nations.N32G45x_Library.2.6.0/middlewares/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group Board
    ../board/: board.c drv_gpio.c drv_hwtimer.c drv_key.c drv_pwm.c drv_spi.c drv_usart.c key_gesture.c
    ../Nations.N32G45x_Library.2.6.0/firmware/CMSIS/device/: system_n32g45x.c
    ../pack/keil/: pack_contract.c retarget_keil.c
    ../Nations.N32G45x_Library.2.6.0/firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c n32g45x_wwdg.c
  group AC5
    generated/: context_ac5.s startup_ac5.s
  group AC6
    generated/: context_ac6.S startup_ac6.S
  group GP21
    ../board/: drv_gp21.c gp21_protocol.c
  group GC9307C
    ../board/: drv_lcd.c drv_lcd_device.c
  group LVGL
    ../board/: lv_port_disp.c lv_port_indev.c
    ../third_party/lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    ../third_party/lvgl/demos/stress/: lv_demo_stress.c
    ../third_party/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../third_party/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../third_party/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../third_party/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../third_party/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../third_party/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../third_party/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../third_party/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../third_party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../third_party/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../third_party/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../third_party/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../third_party/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../third_party/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../third_party/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../third_party/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../third_party/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../third_party/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../third_party/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../third_party/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../third_party/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../third_party/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../third_party/lvgl/src/extra/: lv_extra.c
    ../third_party/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../third_party/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../third_party/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../third_party/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../third_party/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../third_party/lvgl/src/extra/others/msg/: lv_msg.c
    ../third_party/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../third_party/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../third_party/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../third_party/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../third_party/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../third_party/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../third_party/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../third_party/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../third_party/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../third_party/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../third_party/lvgl/src/extra/widgets/led/: lv_led.c
    ../third_party/lvgl/src/extra/widgets/list/: lv_list.c
    ../third_party/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../third_party/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../third_party/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../third_party/lvgl/src/extra/widgets/span/: lv_span.c
    ../third_party/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../third_party/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../third_party/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../third_party/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../third_party/lvgl/src/extra/widgets/win/: lv_win.c
    ../third_party/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../third_party/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../third_party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../third_party/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Application
    ../app/: app_device_test.c app_led.c app_selftest.c app_tasks.c
    ../board/: rtthread_entry.c
  group Configuration
    ../board/: rtconfig.h gc9307c_panel.h lv_conf.h
    ../inc/: board_config.h
    ../pack/keil/: n32g452_rtthread.sct
target AC5_LVGL (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: N32G452VEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.3.0
  cpu: as above
  output: n32g452_rtthread +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X,N32G452,USE_STDPERIPH_DRIVER,N32_USE_RTTHREAD=1,N32_VARIANT_xE,SYSCLK_SRC=2,SYSCLK_FREQ=128000000,HSE_VALUE=8000000,APP_USE_LVGL=1,LV_CONF_INCLUDE_SIMPLE=1
  c misc: --c99 --fpu=SoftVFP --no_multibyte_chars
  c include: as above
  asm misc: --fpu=SoftVFP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: ..\pack\keil\n32g452_rtthread.sct
  link misc: as above
target AC6_Headless (6240000::V6.24::ARMCLANG)
  device: N32G452VEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.3.0
  cpu: as above
  output: n32g452_rtthread +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: -std=c99 -mfloat-abi=soft
  c include: as above
  asm misc: --target=arm-arm-none-eabi -x assembler-with-cpp -mfloat-abi=soft
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: ..\pack\keil\n32g452_rtthread.sct
  link misc: as above
target AC6_LVGL (6240000::V6.24::ARMCLANG)
  device: N32G452VEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.3.0
  cpu: as above
  output: n32g452_rtthread +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: -std=c99 -mfloat-abi=soft
  c include: as above
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: ..\pack\keil\n32g452_rtthread.sct
  link misc: as above
